# Keil uVision project ANO_Hexacopter.uvproj, settings and files
target ANO_Hexacopter (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ANO_Hexacopter +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --cpp
  c include: .\applications;.\drivers;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Math
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group AnoCopter
    ./applications/: AnoCopter.cpp ANO_Config.cpp ANO_Config.h ANO_Scheduler.cpp ANO_Scheduler.h ANO_Filter.cpp ANO_Filter.h ANO_IMU.cpp ANO_IMU.h ANO_DT.cpp ANO_DT.h ANO_Motor.cpp ANO_Motor.h ANO_RC.cpp ANO_RC.h ANO_PID.cpp ANO_PID.h ANO_FlyControl.cpp ANO_FlyControl.h ANO_Param.cpp ANO_Param.h ANO_Navgation.cpp ANO_Navgation.h
  group Math
    ./Math/: ANO_Math.cpp ANO_Math.h ANO_Vector3.cpp ANO_Vector3.h ANO_Rotations.h ANO_Matrix3.cpp ANO_Matrix3.h ANO_Quaternion.cpp ANO_Quaternion.h
  group Drivers
    ./drivers/: board.c board.h stm32f10x_it.c ANO_Drv_I2C_soft.cpp ANO_Drv_I2C_soft.h ANO_Drv_MPU6050.cpp ANO_Drv_MPU6050.h ANO_Drv_SPI2.cpp ANO_Drv_SPI2.h ANO_Drv_Nrf24l01.cpp ANO_Drv_Nrf24l01.h ANO_Drv_PWM.cpp ANO_Drv_PWM.h ANO_Drv_EEPROM.c ANO_Drv_EEPROM.h ANO_Drv_LED.cpp ANO_Drv_LED.h ANO_Drv_MS5611.cpp ANO_Drv_MS5611.h ANO_Drv_Uart3.cpp ANO_Drv_Uart3.h
  group STM32_FWlib
    ./drivers/: stm32f10x_conf.h
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_spi.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
